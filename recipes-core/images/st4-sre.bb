require recipes-core/images/voltumna-sre.inc
require include/runtime.inc
VARIANT = "Slow Trigger v4 (Runtime)"
